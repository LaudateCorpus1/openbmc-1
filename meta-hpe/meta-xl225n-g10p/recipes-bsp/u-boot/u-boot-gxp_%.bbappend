UBOOT_MACHINE = "gxp_gen10p_defconfig"

