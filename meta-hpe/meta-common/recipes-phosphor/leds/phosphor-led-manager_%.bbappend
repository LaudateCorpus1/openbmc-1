FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-temp-fix-hang-during-boot-up-to-restore-led-state.patch"

