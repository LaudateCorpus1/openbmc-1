
FILES_${PN}-chassis_remove = "${bindir}/obmcutil"
FILES_${PN}-bmc_append = " ${bindir}/obmcutil"
